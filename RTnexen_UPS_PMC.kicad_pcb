# Repository Ryan970714/RTnexen_PPS_Tool

File README.md:

# RTnexen PPS Tool

一鍵 Push、Pull 和查看 Status 的 KiCad Git 工具。

One-click Git Push, Pull, and Status tool for KiCad PCB Editor.

---

## Installation / 安裝

請查看 [Installation Wiki](../../wiki/Installation) 了解詳細安裝步驟。

For detailed installation instructions, please refer to the [Installation Wiki](../../wiki/Installation).

---

## Usage / 使用方式

1. 開啟 KiCad PCB Editor
2. 在上方工具列找到 **PPS Tool** 圖示（藍色與橘色箭頭）
3. 依照需求選擇功能：
   - **↑ Push** — 將變更推送到遠端
   - **↓ Pull** — 從遠端拉取最新版本
   - **● Status** — 查看目前分支與變更狀態
4. Push 時需填入 commit message，其餘功能全自動完成

---

1. Open KiCad PCB Editor
2. Find the **PPS Tool** icon (blue and orange arrows) in the top toolbar
3. Select the desired action:
   - **↑ Push** — Push changes to remote
   - **↓ Pull** — Pull latest changes from remote
   - **● Status** — View current branch and changes
4. Only Push requires additional input (commit message); all other actions run automatically

---

## License

MIT License — free to use, modify, and distribute.

Copyright (c) 2026 RT Next-Energy Systems

## KiCad design RTnexen_UPS_PMC.kicad_pcb

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common_THT
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965

Connections:
+3.3V: A1.36 (3V3); also elsewhere on the board
/5V: A1.40 (VBUS); also elsewhere on the board
/ALERT_INA226: A1.5 (GPIO3); also elsewhere on the board
/EN_MP2393: A1.1 (GPIO0); also elsewhere on the board
/PG_MP2393: A1.2 (GPIO1); also elsewhere on the board
/SCL_INA226: A1.7 (GPIO5); also elsewhere on the board
/SDA_INA226: A1.6 (GPIO4); also elsewhere on the board
/SW_MP2393: A1.4 (GPIO2)
unnamed: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND)

Parts:
50mR1: R_Shunt; R_Shunt_Vishay_WSK2512_6332Metric_T1.19mm
C9, C10, C11: 100nF; C_0402_1005Metric
J2: KF301-2P; HANDSON_KF301-2P; PARTREV NA
R9: 10K; R_0402_1005Metric
R10, R11: 4.7K; R_0402_1005Metric
U2: INA226AIDGSR; SOP50P490X110-10N; PARTREV B

Connections:
+3.3V: C11.1, R9.1, R10.1, R11.1, U2.6 (VS); also elsewhere on the board
+BATT: 50mR1.1, J2.1, U2.8 (VBUS)
/ALERT_INA226: R9.2, U2.3 (ALERT); also elsewhere on the board
/Power/VIN: 50mR1.4; also elsewhere on the board
/SCL_INA226: R11.2, U2.5 (SCL); also elsewhere on the board
/SDA_INA226: R10.2, U2.4 (SDA); also elsewhere on the board
GND: C9.2, C10.2, C11.2, J2.2, U2.1 (A1), U2.2 (A0), U2.7 (GND); also elsewhere on the board
unnamed: 50mR1.2, C9.1, U2.10 (IN+)
unnamed: 50mR1.3, C10.1, U2.9 (IN-)

Parts:
C1: 22uF; C_0402_1005Metric
C2: 100nF; C_0402_1005Metric
C3: 6.8nF; C_0402_1005Metric
C4: 1uF; C_0402_1005Metric
C5: 10pF; C_0402_1005Metric
C6, C7: 22uF; C_1210_3225Metric
C8: 1nF; C_0402_1005Metric
D1, D2: LED; LED_0402_1005Metric
J1: USB_A; USB_A_Connfly_DS1095
L1: 4.9uH; L_1210_3225Metric
R1: 604K; R_0402_1005Metric
R2: 15K; R_0402_1005Metric
R3: 20R; R_0402_1005Metric
R4: 40.2K; R_0402_1005Metric
R5: 7.68K; R_0402_1005Metric
R6: 100K; R_0402_1005Metric
R7: 3.3K; R_0402_1005Metric
R8: 330; R_0402_1005Metric
U1: MP2393GTL-P; SOT583_MP2393

Connections:
+3.3V: R6.2; also elsewhere on the board
/5V: C5.1, C6.1, C7.1, J1.1 (VBUS), L1.2, R4.1, R5.2, R8.2; also elsewhere on the board
/EN_MP2393: R1.2, U1.6 (EN); also elsewhere on the board
/PG_MP2393: C8.2, R6.1, U1.1 (PG); also elsewhere on the board
/Power/VIN: C1.1, C2.1, R1.1, R7.2, U1.2 (IN); also elsewhere on the board
GND: C1.2, C2.2, C3.1, C6.2, C7.2, C8.1, D1.1 (K), D2.1 (K), J1.4 (GND), J1.SH (Shield), R5.1, U1.4 (GND); also elsewhere on the board
unnamed: C4.1, R3.1
unnamed: C5.2, R2.1, R4.2
unnamed: D1.2 (A), R7.1
unnamed: D2.2 (A), R8.1
unnamed: R3.2, U1.5 (BST)
unnamed: R2.2, U1.8 (FB)
unnamed: C3.2, U1.7 (SS)
unnamed: C4.2, L1.1, U1.3 (SW)

Notes on the sheet:
LED指示燈

Board: 2 copper layers, 50.0 x 70.0 mm, 35 parts (0 on the bottom side), 21 nets.

## Commit log

2026-05-27 初始化 UPS PMC 專案
2026-05-27 移除備份資料夾
2026-05-29 Initial release v2.1.0
2026-05-29 Release v2.2.0 — update UI colors and settings URL
2026-05-29 test'
2026-05-29 Update PCB layout
